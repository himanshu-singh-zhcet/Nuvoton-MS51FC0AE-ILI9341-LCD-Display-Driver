# Keil uVision project display.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: ms51fcBaseCode +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Device\Include;.\Driver\inc;.\Src
  group Src
    ./Src/: main.c ILI9341.c spi.c
  group Driver
    ./Driver/src/: common.c watchdog.c sys.c
  group StartUp
    ./Startup/: STARTUP.A51
